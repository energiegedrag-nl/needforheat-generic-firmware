#include <measurements.hpp>

#include <cstring>

constexpr const char *TAG = "Measurements";

namespace Measurements
{
	std::unordered_map<std::string, std::string> Measurement::m_formatStrings;

	void Measurement::AddFormatter(const std::string &propertyName, const std::string &formatString)
	{
		m_formatStrings[propertyName] = formatString;
	}

	std::string Measurement::Serialize() const
	{
		std::string out(8, '');
		int64_t ts = static_cast<int64_t>(m_timestamp);
		for (int i = 0; i < 8; i++)
			out[i] = static_cast<char>((ts >> (8 * i)) & 0xFF);
		out += m_propertyName;
		out.push_back('');
		out += m_value;
		return out;
	}

	bool Measurement::Deserialize(const uint8_t *data, size_t length, Measurement &out)
	{
		if (length < 10)
			return false;
		int64_t ts = 0;
		for (int i = 0; i < 8; i++)
			ts |= static_cast<int64_t>(data[i]) << (8 * i);
		const char *rest = reinterpret_cast<const char *>(data + 8);
		size_t restLength = length - 8;
		const void *zero = memchr(rest, '', restLength);
		if (zero == nullptr || zero == rest)
			return false;
		size_t nameLength = static_cast<const char *>(zero) - rest;
		out.m_propertyName.assign(rest, nameLength);
		out.m_value.assign(rest + nameLength + 1, restLength - nameLength - 1);
		out.m_timestamp = static_cast<time_t>(ts);
		return true;
	}

	cJSON *Measurement::GetJSON()
	{
		// Create the object that eventually gets added to "measurements".
		auto measurementObject = cJSON_CreateObject();

		// Add the property object.
		auto propertyObject = cJSON_CreateObject();
		cJSON_AddItemToObject(measurementObject, "property", propertyObject);

		// Add the property name to the property object.
		auto propertyName = cJSON_CreateString(m_propertyName.c_str());
		cJSON_AddItemToObject(propertyObject, "name", propertyName);

		// Add the measurement timestamp to the measurement object.
		auto timestamp = cJSON_CreateNumber(m_timestamp);
		cJSON_AddItemToObject(measurementObject, "time", timestamp);

		// Add the measurement value to the measurement object.
		auto value = cJSON_CreateString(m_value.c_str());
		cJSON_AddItemToObject(measurementObject, "value", value);

		return measurementObject;
	}
} // namespace Measurements
